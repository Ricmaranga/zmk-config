## config/boards/shields/RickysBoard/Kconfig.defconfig
```kconfig
if SHIELD_RICKYSBOARD

config ZMK_KEYBOARD_NAME
    default "RickysBoard"

endif
```
